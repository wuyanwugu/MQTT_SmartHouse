# Keil uVision project 01_freertos_template.uvprojx, settings and files
target 01_freertos_template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 01_freertos_template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/DshanMCU-F103;../Middlewares/MQTTclient/common;../Middlewares/MQTTclient/mqtt;../Middlewares/MQTTclient/mqttclient;../Middlewares/MQTTclient/network;../Middlewares/MQTTclient/platform/FreeRTOS;../Middlewares/MQTTclient/network/mbedtls/include/mbedtls;../Middlewares/MQTTclient/common/log;../Middlewares/MQTTclient/common/PLOOC;..\Middlewares\MQTTclient\HAL_AT
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c i2c.c spi.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/DshanMCU-F103
    ../Drivers/DshanMCU-F103/: driver_led.c driver_oled.c driver_mpu6050.c driver_timer.c driver_ds18b20.c driver_lcd.c driver_dht11.c driver_active_buzzer.c driver_passive_buzzer.c driver_color_led.c driver_ir_receiver.c driver_ir_sender.c driver_light_sensor.c driver_ir_obstacle.c driver_ultrasonic_sr04.c driver_spiflash_w25q64.c driver_rotary_encoder.c driver_irq.c driver_motor.c driver_key.c driver_uart.c circle_buffer.c driver_sg90.c
  group MQTTclient/common
    ../Middlewares/MQTTclient/common/: mqtt_list.c random.c
    ../Middlewares/MQTTclient/common/log/: salof.c fifo.c format.c
    ../Middlewares/MQTTclient/common/log/arch/freertos/: arch.c
  group MQTTclient/mqtt
    ../Middlewares/MQTTclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MQTTclient/mqttclient
    ../Middlewares/MQTTclient/mqttclient/: mqttclient.c
  group MQTTclient/network
    ../Middlewares/MQTTclient/network/: nettype_tcp.c network.c
  group MQTTclient/FreeRtos/platform
    ../Middlewares/MQTTclient/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c platform_esp8266_AT.c
    ../Middlewares/MQTTclient/HAL_AT/: HAL_AT.c
software components: CMSIS:CORE 4.3.0
